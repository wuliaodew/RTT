# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
